Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: f7392cc5-86f7-4b6a-8cdf-1d22d48e5fed, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-15T00:14:03+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12519500_EU1_KWTUS7055F_OBSW:39705510_EU1_12519500_KWTUS7055F_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, Spruce, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Design_Cast, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 819 mm; Depth: 579 mm
Pset_BuildingElementProxyCommon - Reference: 39705510_EU1_12519500_KWTUS7055F_OBSW; sets with these values: 2
